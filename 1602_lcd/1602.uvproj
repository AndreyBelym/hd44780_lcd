# Keil uVision project 1602.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: 1602
  c flags: Optim=1
  c include: C:\ti\TivaWare_C_Series-2.0.1.11577
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: lcd_1602_lm4f.c main.c pll.c systick.c lcd_1602_lm4f.h pll.h systick.h startup_rvmdk.S
